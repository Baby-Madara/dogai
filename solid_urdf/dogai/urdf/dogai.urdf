Commit message: frames edited

File: solid_urdf/dogai/urdf/dogai.urdf (robot description, URDF)
Before this commit: robot dogai, 14 links, 13 joints
Links:
- removed link world
Joints:
- removed joint dummy_joint
